/*!
* \file DataInterpolatorL.h
* \author Marco Cattani <m.cattani@icloud.com>
* \version 3.0
* \date 26/02/2022
* \brief 
* \remarks None
* 
* 
* 
*/

/** \addtogroup Data
 *  @{
 */

#ifndef GRAFICI_DATA_LINEAR_INTERPOLATOR_H
#define GRAFICI_DATA_LINEAR_INTERPOLATOR_H

/*! Importation of librairies*/
#include "DataSelect.h"
#include "DataVector.h"

/**
 * @brief Vector data source vector generated by interpolating the data point of a give data source
 * 
 */
class DataInterpolatorL : public DataSource<DataVector>
{
  public:
	// M>=2 samples include both normalized endpoints. M==1 emits the first knot.
	DataInterpolatorL(const DataSourceNorm &x, const DataSourceNorm &y, size_t interpolationSteps)
		: DataInterpolatorL(x, y, interpolationSteps, size_t(-1))
	{
	}

	const DataVector operator[](const unsigned long idx) const
	{
		size_t bin;
		float weight;
		if (!compute_x_bin(idx, &bin, &weight))
			return DataVector::invalid();
		const float x0 = _x[bin].raw(), x1 = _x[bin + 1].raw();
		const float y0 = _y[bin].raw(), y1 = _y[bin + 1].raw();
		return {{x0 * (1.0f - weight) + x1 * weight, _x.range()},
				{y0 * (1.0f - weight) + y1 * weight, _y.range()}};
	}

	/* methods to get a datasource from the interpolated dataset */
	virtual DataSelect x() const
	{
		return DataSelect(*this, VectorComponents::x);
	}

	virtual DataSelect y() const
	{
		return DataSelect(*this, VectorComponents::y);
	}

  protected:
	const DataSourceNorm &_x;
	const DataSourceNorm &_y;
	size_t _src_size;

	// A derived interpolator can reject excessive source counts before reads.
	DataInterpolatorL(const DataSourceNorm &x, const DataSourceNorm &y,
					   size_t outputs, size_t max_intervals)
		: DataSource<DataVector>{outputs}, _x{x}, _y{y},
		  _src_size{DataSourceNorm::min_data_source_size(x, y)}
	{
		if (_size == 0 || _src_size < 2 || _src_size - 1 > max_intervals || !valid_knots())
			_size = 0;
	}

	bool compute_x_bin(const unsigned long idx, size_t *bin, float *weight) const
	{
		if (idx >= _size || _src_size < 2)
			return false;
		const float target = _size == 1 ? _x[0].norm()
			: static_cast<float>(idx) / static_cast<float>(_size - 1);
		for (size_t i = 0; i < _src_size - 1; ++i)
		{
			const float left = _x[i].norm(), right = _x[i + 1].norm();
			if (isfinite(left) && isfinite(right) && right > left && target >= left && target <= right)
			{
				*bin = i;
				*weight = (target - left) / (right - left);
				return true;
			}
		}
		return false; // No extrapolation beyond the available knot pairs.
	}

  private:
	bool valid_knots() const
	{
		const auto xr = _x.range(), yr = _y.range();
		if (!isfinite(static_cast<float>(xr.low)) || !isfinite(static_cast<float>(xr.high)) ||
			!isfinite(static_cast<float>(yr.low)) || !isfinite(static_cast<float>(yr.high)) ||
			!(xr.high > xr.low) || yr.high < yr.low)
			return false;
		float previous_raw = 0, previous_norm = 0;
		for (size_t i = 0; i < _src_size; ++i)
		{
			const auto x = _x[i], y = _y[i];
			const float raw = x.raw(), norm = x.norm();
			if (!x.valid() || !y.valid() || !isfinite(raw) || !isfinite(norm) || !isfinite(static_cast<float>(y.raw())) ||
				(i > 0 && (!(raw > previous_raw) || !(norm > previous_norm))))
				return false;
			previous_raw = raw;
			previous_norm = norm;
		}
		return true;
	}
};

#endif /* GRAFICI_DATA_LINEAR_INTERPOLATOR_H */

/** @}*/