/*!
* \file DataSpline.h
* \author Marco Cattani <m.cattani@icloud.com>
* \version 3.0
* \date 26/02/2022
* \brief 
* \remarks None
* 
* 
* 
*/

/** \addtogroup Data
 *  @{
 */

#ifndef GRAFICI_DATA_SPLINE_INTERPOLATOR_H
#define GRAFICI_DATA_SPLINE_INTERPOLATOR_H

// https://iquilezles.org/articles/minispline/

/*! Importation of librairies*/
#include <stdlib.h>
#include "DataInterpolatorL.h"

/**
 * @brief Vector data source generated by interpolating the data point of a give data source
 * 
 * @tparam N Output sample count; supports at most N + 1 source points.
 * @tparam AUTOSCALE 
 * @note Invalid source counts or workspace allocation failure produce an empty source.
 */
template <size_t N, bool AUTOSCALE = true>
class DataSpline : public DataInterpolatorL
{
  public:
	DataSpline(const DataSourceNorm &x, const DataSourceNorm &y)
	    : DataInterpolatorL{ x, y, N }
	{
		compute_spline();
	}

	const DataVector operator[](const unsigned long idx) const
	{
		float raw_x, raw_y;
		if (idx >= size() || !evaluate_raw(idx, &raw_x, &raw_y))
			return INVALID_DATA_VECTOR;
		return {{raw_x, _x.range()}, {raw_y, _interpolated_y_range}};
	}

  private:
	// Evaluate before DataNorm applies range clipping. Reused by range discovery.
	bool evaluate_raw(unsigned long idx, float *raw_x, float *raw_y) const
	{
		size_t bin;
		float weight;
		compute_x_bin(idx, &bin, &weight);
		if (_src_size < 2 || bin >= _src_size - 1)
			return false;
		const float x0 = _x[bin].raw();
		const float x1 = _x[bin + 1].raw();
		*raw_x = x0 * (float(1) - weight) + x1 * weight;
		const float dx = *raw_x - x0;
		*raw_y = ((_d[bin] * dx + _c[bin]) * dx + _b[bin]) * dx + _y[bin].raw();
		return true;
	}

	bool spline_data()
	{
		const size_t n = _src_size - 1;
		float *h = static_cast<float *>(malloc(sizeof(float) * n));
		float *A = static_cast<float *>(malloc(sizeof(float) * n));
		float *l = static_cast<float *>(malloc(sizeof(float) * (n + 1)));
		float *u = static_cast<float *>(malloc(sizeof(float) * (n + 1)));
		float *z = static_cast<float *>(malloc(sizeof(float) * (n + 1)));
		if (!h || !A || !l || !u || !z)
		{
			free(h);
			free(A);
			free(l);
			free(u);
			free(z);
			return false;
		}

		/* compute bins' delta */
		for (size_t i = 0; i < n; ++i)
		{
			h[i] = _x[i + 1].raw() - _x[i].raw();
		}

		/* interpolate y */
		for (size_t i = 1; i < n; ++i)
		{
			A[i] = 3 * (_y[i + 1].raw() - _y[i].raw()) / h[i] - 3 * (_y[i].raw() - _y[i - 1].raw()) / h[i - 1];
		}

		l[0] = l[n] = 1;
		u[0] = z[0] = z[n] = _c[n] = 0;
		for (size_t i = 1; i < n; ++i)
		{
			l[i] = 2 * (_x[i + 1].raw() - _x[i - 1].raw()) - h[i - 1] * u[i - 1];
			u[i] = h[i] / l[i];
			z[i] = (A[i] - h[i - 1] * z[i - 1]) / l[i];
		}

		for (size_t j = n; j > 0;)
		{
			--j;
			_c[j] = z[j] - u[j] * _c[j + 1];
			_b[j] = (_y[j + 1].raw() - _y[j].raw()) / h[j] - h[j] * (_c[j + 1] + 2 * _c[j]) / 3;
			_d[j] = (_c[j + 1] - _c[j]) / (3 * h[j]);
		}

		free(h);
		free(A);
		free(l);
		free(u);
		free(z);
		return true;
	}

	void compute_spline()
	{
		// Coefficients include the final knot at index _src_size - 1.
		if (_size == 0 || _src_size < 2 || _src_size - 1 > N || !spline_data())
		{
			_size = 0;
			return;
		}

		/* scan all interpolated y values to find new range */
		_interpolated_y_range = _y[0].range();

		if (AUTOSCALE)
		{
			/* use iteration over []?s */
			for (size_t idx = 0; idx < _size; ++idx)
			{
				float raw_x, raw_y;
				if (evaluate_raw(idx, &raw_x, &raw_y))
					_interpolated_y_range.update(raw_y);
			}
		}
	}

	float _b[N + 1];
	float _c[N + 1];
	float _d[N + 1];
	Range<float> _interpolated_y_range{ 0, 0 };
};

#endif //GRAFICI_DATA_SPLINE_INTERPOLATOR_H

/** @}*/